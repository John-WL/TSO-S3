# Keil uVision project Projet fianl TSO S3.uvproj, settings and files
target Target 1 (MCS-51)
  device: DS89C450 Dallas Semiconductor
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xFFFF) CLOCK(33000000) MODDP2
  output: projet
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: ProjetFinalMain.c ds89c450.h I2C.c I2C.h RxTx232.c RxTx232.h LCD.c LCD.h
