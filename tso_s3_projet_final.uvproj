# Keil uVision project tso_s3_projet_final.uvproj, settings and files
target Target 1 (MCS-51)
  device: DS89C450 Dallas Semiconductor
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xFFFF) CLOCK(33000000) MODDP2
  output: tso_s3_projet_final +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: ProjetFinalMain.c I2C.c KeyboardI2C.c LCD.c RxTx232.c SubOptimizedLcdPrinter.c Timer0.c TypeConversion.c I2C.h KeyboardI2C.h LCD.h ProjectDefinitions.h RxTx232.h SubOptimizedLcdPrinter.h Timer0.h TypeConversion.h CircularBuffer_RxTx.h CircularBuffer_RxTx.c SequenceHandler.c SequenceHandler.h
