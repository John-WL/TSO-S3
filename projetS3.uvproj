# Keil uVision project projetS3.uvproj, settings and files
target Target 1 (MCS-51)
  device: DS89C450 Dallas Semiconductor
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xFFFF) CLOCK(33000000) MODDP2
  output: projetS3 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: I2C.c LCD.c ProjetFinalMain.c RxTx232.c SubOptimizedLcdPrinter.c Timer0.c TypeConversion.c CircularBuffer_RxTx.c CircularBuffer_RxTx.h
